# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; WM_W600; __inline=inline; __inline__=inline; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; packages\webclient-v2.1.1\inc; rt-thread\components\net\sal_socket\include\dfs_net; rt-thread\libcpu\arm\common; ports\fal; ports\sensor; libraries\WM_Libraries\Platform\Drivers\spi; rt-thread\components\finsh; libraries\WM_Libraries\Platform\Common\Params; packages\mbedtls-v2.7.10\ports\inc; packages\qrcode-latest\inc; ports\easyflash; packages\EasyFlash-v4.0.0\inc; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; drivers; packages\infrared-latest\inc; .; libraries\WM_Libraries\Platform\Common\crypto\symmetric; rt-thread\components\libc\compilers\common; libraries\WM_Libraries\Platform\Common\crypto\math; rt-thread\components\drivers\include; packages\netutils-v1.1.0\ntp; libraries\WM_Libraries\Platform\Common\crypto; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\libc\compilers\dlib; rt-thread\components\net\netdev\include; rt-thread\components\drivers\sensors; rt-thread\components\net\lwip-2.0.2\src\arch\include; rt-thread\libcpu\arm\cortex-m3; libraries\WM_Libraries; applications; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\dfs\filesystems\devfs; ports\wifi; rt-thread\components\net\lwip-2.0.2\src\include\netif; rt-thread\components\net\lwip-2.0.2\src\include; rt-thread\components\net\sal_socket\impl; libraries\WM_Libraries\Include\OS; rt-thread\components\net\sal_socket\include; libraries\WM_Libraries\Platform\Inc; libraries\WM_Libraries\Include\Driver; rt-thread\components\dfs\include; libraries\WM_Libraries\Include; packages\mbedtls-v2.7.10\mbedtls\include; rt-thread\components\drivers\wlan; packages\fal-latest\inc; libraries\smartconfig\inc; packages\ap3216c-latest; libraries\WM_Libraries\Platform\Boot\gcc; libraries\WM_Libraries\Include\WiFi; packages\aht10-latest; libraries\WM_Libraries\Include\Platform; libraries\WM_Libraries\Platform\Common\crypto\digest; rt-thread\components\drivers\spi; rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: libraries\smartconfig\libs\libsmartconfig_iar.a; libraries\WM_Libraries\Lib\Wlan\libwlan_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: event_pro.c https_get_wechat.c infrared_pro.c lcd_dis.c main.c sensor_pro.c
  group Drivers
    drivers/: board.c drv_uart.c drv_flash.c pin_map.c drv_wifi.c drv_pin.c drv_hw_timer.c drv_soft_i2c.c drv_spi.c drv_spiflash.c drv_lcd.c drv_pwm.c drv_infrared.c
    ports/sensor/: sensor_port.c
  group smartconfig
    libraries/smartconfig/: smartconfig_demo.c
  group Libraries
    libraries/WM_Libraries/Platform/Drivers/cpu/: wm_cpu.c
    libraries/WM_Libraries/Platform/Drivers/gpio/: wm_gpio.c wm_gpio_afsel.c
    libraries/WM_Libraries/Platform/Drivers/io/: wm_io.c
    libraries/WM_Libraries/Platform/Drivers/irq/: wm_irq.c
    libraries/WM_Libraries/Platform/Drivers/efuse/: wm_efuse.c
    libraries/WM_Libraries/Platform/Drivers/internalflash/: wm_internal_fls.c
    libraries/WM_Libraries/Platform/Drivers/spi/: wm_hostspi.c
    libraries/WM_Libraries/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    libraries/WM_Libraries/Platform/Drivers/dma/: wm_dma.c
    libraries/WM_Libraries/Platform/Drivers/timer/: wm_timer.c
    libraries/WM_Libraries/Platform/Drivers/watchdog/: wm_watchdog.c
    libraries/WM_Libraries/Platform/Drivers/i2c/: wm_i2c.c
    libraries/WM_Libraries/Platform/Drivers/pwm/: wm_pwm.c
    libraries/WM_Libraries/Platform/Drivers/adc/: wm_adc.c
    libraries/WM_Libraries/Platform/Drivers/pmu/: wm_pmu.c
    libraries/WM_Libraries/Platform/Drivers/rtc/: wm_rtc.c
    libraries/WM_Libraries/Platform/Common/Params/: wm_param.c
    libraries/WM_Libraries/Platform/Common/fwup/: wm_fwup.c
    libraries/WM_Libraries/Platform/Common/crypto/: wm_crypto_hard.c
    libraries/WM_Libraries/Platform/Common/crypto/digest/: wm_crypto_hmac.c wm_crypto_md2.c wm_crypto_md4.c sha224.c sha384.c wm_crypto_sha512.c
    libraries/WM_Libraries/Platform/Common/crypto/keyformat/: asn1.c wm_crypto_base64.c wm_crypto_x509.c
    libraries/WM_Libraries/Platform/Common/crypto/math/: pstm_mul_comba.c
    libraries/WM_Libraries/Platform/Common/crypto/prng/: prng.c yarrow.c
    libraries/WM_Libraries/Platform/Common/crypto/pubkey/: dh.c ecc.c pkcs.c pubkey.c wm_crypto_rsa.c
    libraries/WM_Libraries/Platform/Common/crypto/symmetric/: aesGCM.c des3.c idea.c rc2.c seed.c
    libraries/WM_Libraries/rtthread/: rtthread_patch.c
    libraries/WM_Libraries/rtthread/utils/: utils.c
    libraries/WM_Libraries/rtthread/startup/iar/: startup_venus.S
    libraries/WM_Libraries/Platform/Boot/iar/: misc.c
  group aht10
    packages/aht10-latest/: aht10.c sensor_asair_aht10.c
  group ap3216c
    packages/ap3216c-latest/: ap3216c.c sensor_lsc_ap3216c.c
  group EasyFlash
    packages/EasyFlash-v4.0.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/easyflash/: ef_fal_port.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_port.c fal_flash_sfud_port.c
  group Infrared_frame
    packages/infrared-latest/src/: infrared.c nec_decoder.c
  group mbedtls
    packages/mbedtls-v2.7.10/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    packages/mbedtls-v2.7.10/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c tls_certificate.c tls_client.c tls_hardware.c tls_net.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group qrcode
    packages/qrcode-latest/src/: qrcode.c
  group WebClient
    packages/webclient-v2.1.1/src/: webclient.c
  group wifi
    ports/wifi/: wifi_config.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/hwtimer/: hwtimer.c
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c rt_drv_pwm.c
    rt-thread/components/drivers/rtc/: rtc.c alarm.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/wlan/: wlan_dev.c wlan_mgnt.c wlan_cmd.c wlan_prot.c wlan_lwip.c wlan_cfg.c wlan_workqueue.c
  group Sensors
    rt-thread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c proto_mbedtls.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
